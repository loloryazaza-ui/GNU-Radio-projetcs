options:
  parameters:
    author: mikhail
    generate_options: qt_gui
    id: RTL_FM_radio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: channel
  id: variable_qtgui_chooser
  parameters:
    label0: '"Дорожное радио"'
    label1: '"Европа Плюс"'
    label2: '"Шансон"'
    label3: '"Радио рекорд"'
    label4: '"Радио Эрмитаж"'
    num_opts: '5'
    option0: '87500000'
    option1: '100500000'
    option2: '104400000'
    option3: '106300000'
    option4: '90100000'
    orient: Qt.QHBoxLayout
    type: int
    value: '87500000'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable
  parameters:
    value: 69.47e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '50e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 500e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '4'
    gain: '1'
    samp_rate: 2e6
    type: fir_filter_ccf
    width: 1e6
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX_sig after rational resampler"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX_signal after WBFM Receive"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX signal after Low Pass Filter"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX signal"'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    interp: '48'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: channel
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 2e6
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_deemph_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_2, '0']
- [rational_resampler_xxx_0, '0', analog_fm_deemph_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
