options:
  parameters:
    author: mikhail
    generate_options: qt_gui
    id: WBFM_habr
    output_language: python
    title: WBFM_habr
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    comment: |-
      частота дискретизации
      аудио файла
    value: int(44.1e3)
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: рабочая частота
    value: 100e6
  states: {}
- name: quad_rate
  id: variable
  parameters:
    comment: |-
      базовая полоса
      WBFM
      = audio_rate * 5
    value: audio_rate * 5
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Частота дискретизации 
      Hack RF
    value: 2e6
  states: {}
- name: tone_offset
  id: variable
  parameters:
    comment: |-
      Смещение канала от DC
      Чтобы не сидеть на 
      центральной несущей
    value: 100e3
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: audio_rate
    tau: '50e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: quad_rate
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: quad_rate
    tau: '50e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ./tune.mp3
    repeat: 'True'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 200e3, 100e3, window.WIN_HAMMING, 6.76)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 200e3, 100e3, window.WIN_HAMMING, 6.76)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '32768'
    grid: 'True'
    type: complex
    update_time: '0.001'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '32768'
    grid: 'True'
    type: complex
    update_time: '0.001'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    fbw: '0.450'
    interp: '27'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '27'
    fbw: '0.450'
    interp: '3'
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    bandwidth: samp_rate
    center_freq: center_freq
    dev_args: serial = 0000000000000000437c63dc21317bd7
    samp_rate: samp_rate
    type: fc32
    vga: '47'
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: center_freq
    dev_args: serial = 0000000000000000c66c63dc33514b83
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [analog_fm_deemph_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_wfm_rcv_0, '0', analog_fm_deemph_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_wfm_tx_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', soapy_hackrf_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_wfm_rcv_0, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
